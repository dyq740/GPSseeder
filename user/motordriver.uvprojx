# Keil uVision project motordriver.uvprojx, settings and files
target driver (ARM-ADS)
  device: STM32F105RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: motordriver +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER
  c include: ..\lib\ins;..\core;..\user;..\hardware;..\sys\sys;..\sys\usart;..\sys\delay
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group core
    ../core/: core_cm3.c startup_stm32f10x_cl.s
  group lib
    ../lib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group sys
    ../sys/delay/: delay.c
    ../sys/sys/: sys.c
    ../sys/usart/: usart.c
  group hardware
    ../hardware/: gps.c led.c usart2.c pwm.c
